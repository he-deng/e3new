# Keil uVision project pmc006e3.uvprojx, settings and files
target pmc006e3 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F435CGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.4
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pmc006e3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F435CGT7, USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\ecat
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c wk_system.c wk_exint.c wk_spi.c wk_tmr.c wk_gpio.c at32_hw.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_tmr.c at32f435_437_ertc.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_usart.c at32f435_437_pwc.c at32f435_437_adc.c at32f435_437_spi.c at32f435_437_dma.c at32f435_437_edma.c at32f435_437_debug.c at32f435_437_flash.c at32f435_437_crc.c at32f435_437_wwdt.c at32f435_437_wdt.c at32f435_437_exint.c at32f435_437_misc.c at32f435_437_scfg.c at32f435_437_usb.c at32f435_437_acc.c at32f435_437_can.c at32f435_437_dac.c at32f435_437_xmc.c at32f435_437_qspi.c at32f435_437_sdio.c at32f435_437_dvp.c at32f435_437_emac.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group ecat
    ../ecat/: applInterface.h bootmode.c bootmode.h cia402appl.c cia402appl.h coeappl.c coeappl.h ecat_def.h ecatappl.c ecatappl.h ecatcoe.c ecatcoe.h ecatfoe.c ecatfoe.h ecatslv.c ecatslv.h esc.h foeappl.c foeappl.h mailbox.c mailbox.h objdef.c objdef.h sdoserv.c sdoserv.h
